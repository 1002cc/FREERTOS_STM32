# Keil uVision project freertos_sc.uvprojx, settings and files
target FREERTOS_STM32_SC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FREERTOS_STM32_SC +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CODE;..\FWLIB\inc;..\OBJ;..\USER;.\inc;..\SYSTEM\inc;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM4F;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\MALLOC;.\src\u8g2;.\eMPL;.\MQTT;.\CJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./src/: led.c esp8266.c hc_sr04.c key.c pwmsg.c tim.c usart.c oled.c adc.c dht11.c rtc.c iwdg.c i2c.c oled_u8g2.c menu.c rfid.c mqtt_app.c
    ./: main.c system_stm32f4xx.c stm32f4xx_it.c
  group CODE
    ../CODE/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group WFLIB
    ../FWLIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_iwdg.c stm32f4xx_pwr.c
  group STARTUP
    ./: startup_stm32f40_41xxx.s
  group FREERTOS_CORE
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FREERTOS_PROJECT
    ../FREERTOS/portable/MemMang/: heap_4.c
    ../FREERTOS/portable/RVDS/ARM_CM4F/: port.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group U8G2
    ./src/u8g2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_stdio.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group CJSON
    ./CJSON/: cJSON.c
